File: pcb_files/mouse/mouse.sch (KiCad schematic (older format))
At the start: 7 parts, among them U1 Teensy3.2, U2 SN754410NE, U3 LM7805_TO220

Commit message: connections on encoders
Parts:
- added M1, M2: Motor_DC, symbol Motor:Motor_DC
Connections:
- net labels added: 3.3v, 5v, M1_backward, M1_encoder_A, M1_encoder_B, M1_forward, M1_speed, M2_backward, M2_encoder_A, M2_encoder_B, M2_forward, M2_speed, OUT1, OUT2, OUT3, OUT4, u1_CE, u1_CS, u1_MISO, u1_MOSI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
- wire segments 9 -> 35
- no-connect marks 0 -> 4
Other:
- moved on the sheet: U2, U?
Changed lines of the file:
@@
 L SN754410NE:SN754410NE U2
 U 1 1 5D1BEE18
-P 2300 6250
-F 0 "U2" H 2300 7220 50  0000 C CNN
-F 1 "SN754410NE" H 2300 7129 50  0000 C CNN
-F 2 "DIP254P762X508-16" H 2300 6250 50  0001 L BNN
-F 3 "PDIP-16 Texas Instruments" H 2300 6250 50  0001 L BNN
-F 4 "Texas Instruments" H 2300 6250 50  0001 L BNN "Field4"
-F 5 "None" H 2300 6250 50  0001 L BNN "Field5"
-F 6 "Unavailable" H 2300 6250 50  0001 L BNN "Field6"
-F 7 "Peripheral Drivers and Actuators Quad Half-Hs" H 2300 6250 50  0001 L BNN "Field7"
-F 8 "SN754410NE" H 2300 6250 50  0001 L BNN "Field8"
-	1    2300 6250
+P 6050 5200
+F 0 "U2" H 6050 6170 50  0000 C CNN
+F 1 "SN754410NE" H 6050 6079 50  0000 C CNN
+F 2 "DIP254P762X508-16" H 6050 5200 50  0001 L BNN
+F 3 "PDIP-16 Texas Instruments" H 6050 5200 50  0001 L BNN
+F 4 "Texas Instruments" H 6050 5200 50  0001 L BNN "Field4"
+F 5 "None" H 6050 5200 50  0001 L BNN "Field5"
+F 6 "Unavailable" H 6050 5200 50  0001 L BNN "Field6"
+F 7 "Peripheral Drivers and Actuators Quad Half-Hs" H 6050 5200 50  0001 L BNN "Field7"
+F 8 "SN754410NE" H 6050 5200 50  0001 L BNN "Field8"
+	1    6050 5200
 	1    0    0    -1
 $EndComp
@@
 L encoder_3081:Encoder_3081 U?
 U 1 1 5D1C0154
-P 2950 1300
-F 0 "U?" H 2950 1917 50  0000 C CNN
-F 1 "Encoder_3081" H 2950 1826 50  0000 C CNN
-F 2 "Package_SO:SSOP-16_5.3x6.2mm_P0.65mm" H 3100 800 50  0001 L CNN
-F 3 "http://ams.com/eng/content/download/438063/1340357/246195" H 800 2900 50  0001 C CNN
-	1    2950 1300
+P 3600 6100
+F 0 "U?" H 3600 6717 50  0000 C CNN
+F 1 "Encoder_3081" H 3600 6626 50  0000 C CNN
+F 2 "Package_SO:SSOP-16_5.3x6.2mm_P0.65mm" H 3750 5600 50  0001 L CNN
+F 3 "http://ams.com/eng/content/download/438063/1340357/246195" H 1450 7700 50  0001 C CNN
+	1    3600 6100
 	1    0    0    -1
 $EndComp
@@
 L encoder_3081:Encoder_3081 U?
 U 1 1 5D1C0226
-P 2900 2450
-F 0 "U?" H 2900 3067 50  0000 C CNN
-F 1 "Encoder_3081" H 2900 2976 50  0000 C CNN
-F 2 "Package_SO:SSOP-16_5.3x6.2mm_P0.65mm" H 3050 1950 50  0001 L CNN
-F 3 "http://ams.com/eng/content/download/438063/1340357/246195" H 750 4050 50  0001 C CNN
-	1    2900 2450
+P 3650 4650
+F 0 "U?" H 3650 5267 50  0000 C CNN
+F 1 "Encoder_3081" H 3650 5176 50  0000 C CNN
+F 2 "Package_SO:SSOP-16_5.3x6.2mm_P0.65mm" H 3800 4150 50  0001 L CNN
+F 3 "http://ams.com/eng/content/download/438063/1340357/246195" H 1500 6250 50  0001 C CNN
+	1    3650 4650
 	1    0    0    -1
 $EndComp
@@
 L RF:NRF24L01_Breakout U?
 U 1 1 5D1C0351
-P 10450 2600
-F 0 "U?" H 10928 2578 50  0000 L CNN
-F 1 "NRF24L01_Breakout" H 10928 2487 50  0000 L CNN
-F 2 "RF_Module:nRF24L01_Breakout" H 10600 3200 50  0001 L CIN
-F 3 "http://www.nordicsemi.com/eng/content/download/2730/34105/file/nRF24L01_Product_Specification_v2_0.pdf" H 10450 2500 50  0001 C CNN
-	1    10450 2600
+P 4850 1850
+F 0 "U?" H 5328 1828 50  0000 L CNN
+F 1 "NRF24L01_Breakout" H 5328 1737 50  0000 L CNN
+F 2 "RF_Module:nRF24L01_Breakout" H 5000 2450 50  0001 L CIN
+F 3 "http://www.nordicsemi.com/eng/content/download/2730/34105/file/nRF24L01_Product_Specification_v2_0.pdf" H 4850 1750 50  0001 C CNN
+	1    4850 1850
 	1    0    0    -1
 $EndComp
@@
 	10250 6200 9000 6200
 Wire Wire Line
-	9000 6200 9000 5950
+	9000 6200 9000 6100
+Text Label 4850 1250 0    50   ~ 0
+3.3v
+Text Label 7550 3450 2    50   ~ 0
+3.3v
+Text Label 4850 2450 0    50   ~ 0
+GND
+Text Label 7550 3250 2    50   ~ 0
+u1_MISO
+Text Label 7550 3150 2    50   ~ 0
+u1_MOSI
+Text Label 7550 3850 2    50   ~ 0
+u1_SCK
+Text Label 7550 3050 2    50   ~ 0
+u1_CS
+Text Label 7550 2950 2    50   ~ 0
+u1_CE
+Text Label 4350 1550 2    50   ~ 0
+u1_MOSI
+Text Label 4350 1650 2    50   ~ 0
+u1_MISO
+Text Label 4350 1750 2    50   ~ 0
+u1_SCK
+Text Label 4350 1850 2    50   ~ 0
+u1_CS
+Text Label 4350 2050 2    50   ~ 0
+u1_CE
+Text Label 5300 4600 2    50   ~ 0
+5v
+Wire Wire Line
+	7900 5500 7600 5500
+Connection ~ 7900 5500
+Text Label 7600 5500 2    50   ~ 0
+vBatt
+Text Label 5350 4700 2    50   ~ 0
+5v
+Text Label 5350 4900 2    50   ~ 0
+M1_speed
+Text Label 5350 5000 2    50   ~ 0
+M2_speed
+Wire Wire Line
+	9000 6100 9300 6100
+Wire Wire Line
+	9300 6100 9300 5950
+Wire Wire Line
+	9300 5950 9450 5950
+Connection ~ 9000 6100
+Wire Wire Line
+	9000 6100 9000 5950
+Text Label 9450 5950 0    50   ~ 0
+5v
+Text Label 5350 5200 2    50   ~ 0
+M1_forward
+Text Label 5350 5300 2    50   ~ 0
+M1_backward
+Text Label 5350 5400 2    50   ~ 0
+M2_forward
+Text Label 5350 5500 2    50   ~ 0
+M2_backward
+Wire Wire Line
+	5350 5700 5200 5700
+Wire Wire Line
+	5200 5700 5200 5800
+Wire Wire Line
+	5200 6000 5350 6000
+Wire Wire Line
+	5350 5900 5200 5900
+Connection ~ 5200 5900
+Wire Wire Line
+	5200 5900 5200 6000
+Wire Wire Line
+	5350 5800 5200 5800
+Connection ~ 5200 5800
+Wire Wire Line
+	5200 5800 5200 5850
+Wire Wire Line
+	5200 5850 5050 5850
+Connection ~ 5200 5850
+Wire Wire Line
+	5200 5850 5200 5900
+Text Label 5050 5850 2    50   ~ 0
+GND
+Text Label 9550 4350 0    50   ~ 0
+M1_speed
+Text Label 9550 4450 0    50   ~ 0
+M2_speed
+NoConn ~ 7550 3950
+NoConn ~ 7550 4050
+NoConn ~ 7550 4150
+NoConn ~ 7550 4250
+Text Label 6750 4600 0    50   ~ 0
+OUT1
+Text Label 6750 4700 0    50   ~ 0
+OUT2
+Text Label 6750 4800 0    50   ~ 0
+OUT3
+Text Label 6750 4900 0    50   ~ 0
+OUT4
+Text Label 4250 4850 0    50   ~ 0
+OUT1
+Text Label 4250 4750 0    50   ~ 0
+OUT2
+Text Label 4200 6300 0    50   ~ 0
+OUT3
+Text Label 4200 6200 0    50   ~ 0
+OUT4
+Text Label 4250 4650 0    50   ~ 0
+5v
+Text Label 4200 6100 0    50   ~ 0
+5v
+$Comp
+L Motor:Motor_DC M1
+U 1 1 5D1C3AFC
+P 2350 4650
+F 0 "M1" H 2508 4646 50  0000 L CNN
+F 1 "Motor_DC" H 2508 4555 50  0000 L CNN
+F 2 "" H 2350 4560 50  0001 C CNN
+F 3 "~" H 2350 4560 50  0001 C CNN
+	1    2350 4650
+	1    0    0    -1
+$EndComp
+$Comp
+L Motor:Motor_DC M2
+U 1 1 5D1C3BC7
+P 2350 6050
+F 0 "M2" H 2508 6046 50  0000 L CNN
+F 1 "Motor_DC" H 2508 5955 50  0000 L CNN
+F 2 "" H 2350 5960 50  0001 C CNN
+F 3 "~" H 2350 5960 50  0001 C CNN
+	1    2350 6050
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	3050 4500 2700 4500
+Wire Wire Line
+	2700 4500 2700 4450
+Wire Wire Line
+	2700 4450 2350 4450
+Wire Wire Line
+	3050 4800 2700 4800
+Wire Wire Line
+	2700 4800 2700 4950
+Wire Wire Line
+	2700 4950 2350 4950
+Wire Wire Line
+	3000 5950 2700 5950
+Wire Wire Line
+	2700 5950 2700 5850
+Wire Wire Line
+	2700 5850 2350 5850
+Wire Wire Line
+	2350 6350 2700 6350
+Wire Wire Line
+	2700 6350 2700 6250
+Wire Wire Line
+	2700 6250 3000 6250
+Text Label 4250 4550 0    50   ~ 0
+M1_encoder_A
+Text Label 4250 4450 0    50   ~ 0
+M1_encoder_B
+Text Label 4250 4350 0    50   ~ 0
+GND
+Text Label 4200 5800 0    50   ~ 0
+GND
+Text Label 4200 5900 0    50   ~ 0
+M2_encoder_B
+Text Label 4200 6000 0    50   ~ 0
+M2_encoder_A
 $EndSCHEMATC

Commit message: labeled pins
Parts:
- added D0, D1, D2, D3: IRL81A, LED_THT:LED_SideEmitter_Rectangular_W4.5mm_H1.6mm, symbol LED:IRL81A
- added Q0, Q1, Q2, Q3: Q_Photo_NPN, symbol Device:Q_Photo_NPN
- added R0, R1, R2, R3, R4, R5, R6, R7: R, symbol Device:R
Connections:
- net labels added: Emiter_2, Emitter_0, Emitter_1, Emitter_2, Emitter_3, Reciever_0, Reciever_1, Reciever_2, Reciever_3
- wire segments 35 -> 70
- no-connect marks 4 -> 0
Other:
- moved on the sheet: M1, M2, U2, U?

Commit message: connected symbols to footprints
Parts:
- removed U3: LM7805_TO220, Package_TO_SOT_THT:TO-220-3_Vertical, symbol Regulator_Linear:LM7805_TO220
- added U3: LM1084-5.0, Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical, symbol Regulator_Linear:LM1084-5.0
- BT1: renamed from BT?; footprint (none) -> Connector_PinSocket_2.54mm:PinSocket_1x02_P2.54mm_Vertical
- D0, D1, D2, D3: footprint LED_THT:LED_SideEmitter_Rectangular_W4.5mm_H1.6mm -> LED_THT:LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm
- Q0, Q1, Q2, Q3: footprint (none) -> LED_THT:LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm
- R0, R1, R2, R3, R4, R5, R6, R7: footprint (none) -> Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
- U1: footprint (none) -> teensy:Teensy30_31_32_LC
- U2: footprint DIP254P762X508-16 -> SN754410NE.kicad_mod:DIP254P762X508-16
- U4, U5: renamed from U?; footprint Package_SO:SSOP-16_5.3x6.2mm_P0.65mm -> Connector_PinHeader_2.00mm:PinHeader_1x06_P2.00mm_Vertical
- U6: renamed from U?; footprint RF_Module:nRF24L01_Breakout -> Connector_PinSocket_2.54mm:PinSocket_2x04_P2.54mm_Vertical
Changed lines of the file:
@@
 F 0 "U1" H 8550 4837 60  0000 C CNN
 F 1 "Teensy3.2" H 8550 4731 60  0000 C CNN
-F 2 "" H 8550 2450 60  0000 C CNN
+F 2 "teensy:Teensy30_31_32_LC" H 8550 2450 60  0001 C CNN
 F 3 "" H 8550 2450 60  0000 C CNN
 	1    8550 3250
@@
 F 0 "U2" H 5000 6670 50  0000 C CNN
 F 1 "SN754410NE" H 5000 6579 50  0000 C CNN
-F 2 "DIP254P762X508-16" H 5000 5700 50  0001 L BNN
+F 2 "SN754410NE.kicad_mod:DIP254P762X508-16" H 5000 5700 50  0001 L BNN
 F 3 "PDIP-16 Texas Instruments" H 5000 5700 50  0001 L BNN
 F 4 "Texas Instruments" H 5000 5700 50  0001 L BNN "Field4"
@@
 $EndComp
 $Comp
-L Regulator_Linear:LM7805_TO220 U3
-U 1 1 5D1BF038
-P 9000 5650
-F 0 "U3" V 8954 5755 50  0000 L CNN
-F 1 "LM7805_TO220" V 9045 5755 50  0000 L CNN
-F 2 "Package_TO_SOT_THT:TO-220-3_Vertical" H 9000 5875 50  0001 C CIN
-F 3 "http://www.fairchildsemi.com/ds/LM/LM7805.pdf" H 9000 5600 50  0001 C CNN
-	1    9000 5650
-	0    1    1    0
-$EndComp
-$Comp
-L encoder_3081:Encoder_3081 U?
+L encoder_3081:Encoder_3081 U4
 U 1 1 5D1C0154
 P 2550 6600
-F 0 "U?" H 2550 7217 50  0000 C CNN
+F 0 "U4" H 2550 7217 50  0000 C CNN
 F 1 "Encoder_3081" H 2550 7126 50  0000 C CNN
-F 2 "Package_SO:SSOP-16_5.3x6.2mm_P0.65mm" H 2700 6100 50  0001 L CNN
+F 2 "Connector_PinHeader_2.00mm:PinHeader_1x06_P2.00mm_Vertical" H 2700 6100 50  0001 L CNN
 F 3 "http://ams.com/eng/content/download/438063/1340357/246195" H 400 8200 50  0001 C CNN
 	1    2550 6600
@@
 $EndComp
 $Comp
-L encoder_3081:Encoder_3081 U?
+L encoder_3081:Encoder_3081 U5
 U 1 1 5D1C0226
 P 2600 5150
-F 0 "U?" H 2600 5767 50  0000 C CNN
+F 0 "U5" H 2600 5767 50  0000 C CNN
 F 1 "Encoder_3081" H 2600 5676 50  0000 C CNN
-F 2 "Package_SO:SSOP-16_5.3x6.2mm_P0.65mm" H 2750 4650 50  0001 L CNN
+F 2 "Connector_PinHeader_2.00mm:PinHeader_1x06_P2.00mm_Vertical" H 2750 4650 50  0001 L CNN
 F 3 "http://ams.com/eng/content/download/438063/1340357/246195" H 450 6750 50  0001 C CNN
 	1    2600 5150
@@
 $EndComp
 $Comp
-L RF:NRF24L01_Breakout U?
+L RF:NRF24L01_Breakout U6
 U 1 1 5D1C0351
 P 6400 1750
-F 0 "U?" H 6878 1728 50  0000 L CNN
+F 0 "U6" H 6878 1728 50  0000 L CNN
 F 1 "NRF24L01_Breakout" H 6878 1637 50  0000 L CNN
-F 2 "RF_Module:nRF24L01_Breakout" H 6550 2350 50  0001 L CIN
+F 2 "Connector_PinSocket_2.54mm:PinSocket_2x04_P2.54mm_Vertical" H 6550 2350 50  0001 L CIN
 F 3 "http://www.nordicsemi.com/eng/content/download/2730/34105/file/nRF24L01_Product_Specification_v2_0.pdf" H 6400 1650 50  0001 C CNN
 	1    6400 1750
@@
 $EndComp
 $Comp
-L Device:Battery_Cell BT?
+L Device:Battery_Cell BT1
 U 1 1 5D1C070D
 P 7900 5700
-F 0 "BT?" H 8018 5796 50  0000 L CNN
+F 0 "BT1" H 8018 5796 50  0000 L CNN
 F 1 "Battery_Cell" H 8018 5705 50  0000 L CNN
-F 2 "" V 7900 5760 50  0001 C CNN
+F 2 "Connector_PinSocket_2.54mm:PinSocket_1x02_P2.54mm_Vertical" V 7900 5760 50  0001 C CNN
 F 3 "~" V 7900 5760 50  0001 C CNN
 	1    7900 5700
@@
 F 0 "R0" H 1620 1346 50  0000 L CNN
 F 1 "R" H 1620 1255 50  0000 L CNN
-F 2 "" V 1480 1300 50  0001 C CNN
+F 2 "Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical" V 1480 1300 50  0001 C CNN
 F 3 "~" H 1550 1300 50  0001 C CNN
 	1    1550 1300
@@
 F 0 "R1" H 2120 1346 50  0000 L CNN
 F 1 "R" H 2120 1255 50  0000 L CNN
-F 2 "" V 1980 1300 50  0001 C CNN
+F 2 "Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical" V 1980 1300 50  0001 C CNN
 F 3 "~" H 2050 1300 50  0001 C CNN
 	1    2050 1300
@@
 F 0 "R3" H 3120 1346 50  0000 L CNN
 F 1 "R" H 3120 1255 50  0000 L CNN
-F 2 "" V 2980 1300 50  0001 C CNN
+F 2 "Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical" V 2980 1300 50  0001 C CNN
 F 3 "~" H 3050 1300 50  0001 C CNN
 	1    3050 1300
@@
 F 0 "R2" H 2620 1346 50  0000 L CNN
 F 1 "R" H 2620 1255 50  0000 L CNN
-F 2 "" V 2480 1300 50  0001 C CNN
+F 2 "Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical" V 2480 1300 50  0001 C CNN
 F 3 "~" H 2550 1300 50  0001 C CNN
 	1    2550 1300
@@
 F 0 "D3" V 2954 1052 50  0000 L CNN
 F 1 "IRL81A" V 3045 1052 50  0000 L CNN
-F 2 "LED_THT:LED_SideEmitter_Rectangular_W4.5mm_H1.6mm" H 3050 1075 50  0001 C CNN
+F 2 "LED_THT:LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm" H 3050 1075 50  0001 C CNN
 F 3 "http://www.osram-os.com/Graphics/XPic0/00203825_0.pdf" H 3000 900 50  0001 C CNN
 	1    3050 900
@@
 F 0 "D2" V 2454 1052 50  0000 L CNN
 F 1 "IRL81A" V 2545 1052 50  0000 L CNN
-F 2 "LED_THT:LED_SideEmitter_Rectangular_W4.5mm_H1.6mm" H 2550 1075 50  0001 C CNN
+F 2 "LED_THT:LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm" H 2550 1075 50  0001 C CNN
 F 3 "http://www.osram-os.com/Graphics/XPic0/00203825_0.pdf" H 2500 900 50  0001 C CNN
 	1    2550 900
@@
 F 0 "D1" V 1954 1052 50  0000 L CNN
 F 1 "IRL81A" V 2045 1052 50  0000 L CNN
-F 2 "LED_THT:LED_SideEmitter_Rectangular_W4.5mm_H1.6mm" H 2050 1075 50  0001 C CNN
+F 2 "LED_THT:LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm" H 2050 1075 50  0001 C CNN
 F 3 "http://www.osram-os.com/Graphics/XPic0/00203825_0.pdf" H 2000 900 50  0001 C CNN
 	1    2050 900
@@
 F 0 "D0" V 1454 1052 50  0000 L CNN
 F 1 "IRL81A" V 1545 1052 50  0000 L CNN
-F 2 "LED_THT:LED_SideEmitter_Rectangular_W4.5mm_H1.6mm" H 1550 1075 50  0001 C CNN
+F 2 "LED_THT:LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm" H 1550 1075 50  0001 C CNN
 F 3 "http://www.osram-os.com/Graphics/XPic0/00203825_0.pdf" H 1500 900 50  0001 C CNN
 	1    1550 900
@@
 F 0 "Q0" H 1423 3354 50  0000 R CNN
 F 1 "Q_Photo_NPN" H 1423 3445 50  0000 R CNN
-F 2 "" H 1800 3500 50  0001 C CNN
+F 2 "LED_THT:LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm" H 1800 3500 50  0001 C CNN
 F 3 "~" H 1600 3400 50  0001 C CNN
 	1    1600 3400
@@
 F 0 "Q1" H 2323 3354 50  0000 R CNN
 F 1 "Q_Photo_NPN" H 2323 3445 50  0000 R CNN
-F 2 "" H 2700 3500 50  0001 C CNN
+F 2 "LED_THT:LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm" H 2700 3500 50  0001 C CNN
 F 3 "~" H 2500 3400 50  0001 C CNN
 	1    2500 3400
@@
 F 0 "Q2" H 3223 3354 50  0000 R CNN
 F 1 "Q_Photo_NPN" H 3223 3445 50  0000 R CNN
-F 2 "" H 3600 3500 50  0001 C CNN
+F 2 "LED_THT:LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm" H 3600 3500 50  0001 C CNN
 F 3 "~" H 3400 3400 50  0001 C CNN
 	1    3400 3400
@@
 F 0 "Q3" H 4073 3354 50  0000 R CNN
 F 1 "Q_Photo_NPN" H 4073 3445 50  0000 R CNN
-F 2 "" H 4450 3500 50  0001 C CNN
+F 2 "LED_THT:LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm" H 4450 3500 50  0001 C CNN
 F 3 "~" H 4250 3400 50  0001 C CNN
 	1    4250 3400
@@
 F 0 "R4" H 1570 2846 50  0000 L CNN
 F 1 "R" H 1570 2755 50  0000 L CNN
-F 2 "" V 1430 2800 50  0001 C CNN
+F 2 "Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical" V 1430 2800 50  0001 C CNN
 F 3 "~" H 1500 2800 50  0001 C CNN
 	1    1500 2800
@@
 F 0 "R5" H 2470 2846 50  0000 L CNN
 F 1 "R" H 2470 2755 50  0000 L CNN
-F 2 "" V 2330 2800 50  0001 C CNN
+F 2 "Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical" V 2330 2800 50  0001 C CNN
 F 3 "~" H 2400 2800 50  0001 C CNN
 	1    2400 2800
@@
 F 0 "R6" H 3370 2846 50  0000 L CNN
 F 1 "R" H 3370 2755 50  0000 L CNN
-F 2 "" V 3230 2800 50  0001 C CNN
+F 2 "Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical" V 3230 2800 50  0001 C CNN
 F 3 "~" H 3300 2800 50  0001 C CNN
 	1    3300 2800
@@
 F 0 "R7" H 4220 2846 50  0000 L CNN
 F 1 "R" H 4220 2755 50  0000 L CNN
-F 2 "" V 4080 2800 50  0001 C CNN
+F 2 "Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical" V 4080 2800 50  0001 C CNN
 F 3 "~" H 4150 2800 50  0001 C CNN
 	1    4150 2800
@@
 Text Label 9550 4550 0    50   ~ 0
 Emitter_3
+$Comp
+L Regulator_Linear:LM1084-5.0 U3
+U 1 1 5D2418A8
+P 9000 5650
+F 0 "U3" V 8954 5755 50  0000 L CNN
+F 1 "LM1084-5.0" V 9045 5755 50  0000 L CNN
+F 2 "Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical" H 9000 5900 50  0001 C CIN
+F 3 "http://www.ti.com/lit/ds/symlink/lm1084.pdf" H 9000 5650 50  0001 C CNN
+	1    9000 5650
+	0    1    1    0
+$EndComp
 $EndSCHEMATC

Commit message: caster ball footprint
Parts:
- added M3: Motor_DC, misc:Mouse_caster, symbol Motor:Motor_DC
- M1, M2: footprint (none) -> misc:Motor_mouse
Changed lines of the file:
@@
 EESchema Schematic File Version 4
+LIBS:mouse-cache
 EELAYER 26 0
 EELAYER END
@@
 F 0 "M1" H 1458 5146 50  0000 L CNN
 F 1 "Motor_DC" H 1458 5055 50  0000 L CNN
-F 2 "" H 1300 5060 50  0001 C CNN
+F 2 "misc:Motor_mouse" H 1300 5060 50  0001 C CNN
 F 3 "~" H 1300 5060 50  0001 C CNN
 	1    1300 5150
@@
 F 0 "M2" H 1458 6546 50  0000 L CNN
 F 1 "Motor_DC" H 1458 6455 50  0000 L CNN
-F 2 "" H 1300 6460 50  0001 C CNN
+F 2 "misc:Motor_mouse" H 1300 6460 50  0001 C CNN
 F 3 "~" H 1300 6460 50  0001 C CNN
 	1    1300 6550
@@
 	0    1    1    0
 $EndComp
+$Comp
+L Motor:Motor_DC M3
+U 1 1 5D240B05
+P 1100 4150
+F 0 "M3" H 1258 4146 50  0000 L CNN
+F 1 "Motor_DC" H 1258 4055 50  0000 L CNN
+F 2 "misc:Mouse_caster" H 1100 4060 50  0001 C CNN
+F 3 "~" H 1100 4060 50  0001 C CNN
+	1    1100 4150
+	1    0    0    -1
+$EndComp
 $EndSCHEMATC

Commit message: added status LEDs, buzzer
Parts:
- added BZ1: Buzzer, symbol Device:Buzzer
- added D4: STATUS_0, symbol Device:LED
- added D5: STATUS_1, symbol Device:LED
- added R10, R8, R9: R, symbol Device:R
- M3: value Motor_DC -> CASTER_BALL
Connections:
- net labels added: Buzzer, STATUS_LED_0, STATUS_LED_1
- wire segments 70 -> 72
Changed lines of the file:
@@
 Text Label 5900 1950 2    50   ~ 0
 u1_CE
-Text Label 4250 5100 2    50   ~ 0
+Text Label 4300 5100 2    50   ~ 0
 5v
 Wire Wire Line
@@
 P 1100 4150
 F 0 "M3" H 1258 4146 50  0000 L CNN
-F 1 "Motor_DC" H 1258 4055 50  0000 L CNN
+F 1 "CASTER_BALL" H 1258 4055 50  0000 L CNN
 F 2 "misc:Mouse_caster" H 1100 4060 50  0001 C CNN
 F 3 "~" H 1100 4060 50  0001 C CNN
@@
 	1    0    0    -1
 $EndComp
+$Comp
+L Device:Buzzer BZ1
+U 1 1 5D27C02F
+P 6700 3550
+F 0 "BZ1" H 6853 3579 50  0000 L CNN
+F 1 "Buzzer" H 6853 3488 50  0000 L CNN
+F 2 "" V 6675 3650 50  0001 C CNN
+F 3 "~" V 6675 3650 50  0001 C CNN
+	1    6700 3550
+	0    1    1    0
+$EndComp
+$Comp
+L Device:R R10
+U 1 1 5D28EC87
+P 6800 3200
+F 0 "R10" V 6593 3200 50  0000 C CNN
+F 1 "R" V 6684 3200 50  0000 C CNN
+F 2 "" V 6730 3200 50  0001 C CNN
+F 3 "~" H 6800 3200 50  0001 C CNN
+	1    6800 3200
+	-1   0    0    1
+$EndComp
+Wire Wire Line
+	6800 3450 6800 3350
+Text Label 6600 3450 1    50   ~ 0
+GND
+Wire Wire Line
+	6800 2850 6800 3050
+$Comp
+L Device:LED D4
+U 1 1 5D292553
+P 5900 3650
+F 0 "D4" H 5891 3866 50  0000 C CNN
+F 1 "STATUS_0" H 5900 3800 50  0000 C CNN
+F 2 "" H 5900 3650 50  0001 C CNN
+F 3 "~" H 5900 3650 50  0001 C CNN
+	1    5900 3650
+	0    -1   -1   0
+$EndComp
+$Comp
+L Device:R R8
+U 1 1 5D292B44
+P 5900 3350
+F 0 "R8" H 5830 3304 50  0000 R CNN
+F 1 "R" H 5830 3395 50  0000 R CNN
+F 2 "" V 5830 3350 50  0001 C CNN
+F 3 "~" H 5900 3350 50  0001 C CNN
+	1    5900 3350
+	-1   0    0    1
+$EndComp
+$Comp
+L Device:LED D5
+U 1 1 5D2990A5
+P 6300 3650
+F 0 "D5" H 6291 3866 50  0000 C CNN
+F 1 "STATUS_1" H 6300 3800 50  0000 C CNN
+F 2 "" H 6300 3650 50  0001 C CNN
+F 3 "~" H 6300 3650 50  0001 C CNN
+	1    6300 3650
+	0    -1   -1   0
+$EndComp
+$Comp
+L Device:R R9
+U 1 1 5D2990AB
+P 6300 3350
+F 0 "R9" H 6230 3304 50  0000 R CNN
+F 1 "R" H 6230 3395 50  0000 R CNN
+F 2 "" V 6230 3350 50  0001 C CNN
+F 3 "~" H 6300 3350 50  0001 C CNN
+	1    6300 3350
+	-1   0    0    1
+$EndComp
+Text Label 5900 3200 1    50   ~ 0
+STATUS_LED_0
+Text Label 6300 3200 1    50   ~ 0
+STATUS_LED_1
+Text Label 5900 3800 3    50   ~ 0
+GND
+Text Label 6300 3800 3    50   ~ 0
+GND
+Text Label 7550 2350 2    50   ~ 0
+STATUS_LED_0
+Text Label 7550 2450 2    50   ~ 0
+STATUS_LED_1
+Text Label 6800 2850 1    50   ~ 0
+Buzzer
+Text Label 7550 2550 2    50   ~ 0
+Buzzer
 $EndSCHEMATC
