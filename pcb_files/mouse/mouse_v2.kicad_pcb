# Repository lowJ/fish-mouse

File README.md:

# fish-mouse

<details><summary> PCB traces </summary> 

</details>

Issues to fix
1. Switche footprint needs bigger drill holes.
1. Add switch to choose USBC GND or Batt GND.(Currently switch toggles between USB 5V and Regulator 5V, but GND stays the same). It will be safer if GNDs can be disconnected when not in use.
1. Fix footprint of USBC, add drill holes for excess pins, but do not include metal surrounding. Extend smd pads.
1. On USBC footprint, one of THT pads is off.
1. Put i2c pullups on other side of pcb
1. led to show when there is usb power
1. probally more issues yet to be found...

<h2> Parts and Labels [Labels not fully updated!] </h2>

Note: This is not a full parts list
* [__SN754410NE__](https://www.digikey.com/product-detail/en/texas-instruments/SN754410NE/296-9911-5-ND/380180) _(U2)_ - Motor driver, used to control the speed and direction of the two motors.
* [__Teensy 3.2__](https://www.pjrc.com/teensy/teensy31.html) _(U1)_- Processor, will run code.
* [__IR Emitters__]() _(D0-D3)_ - Send an IR signal, which will bounce off walls, allowing for the reciever to read. Each is connected to a digital pin on the Teensy, allowing them to individual turn on and off.
* [__IR Reciever__]() _(Q0-Q3)_ - Reads how strong the IR signal is, depending on the value it reads it is able to detect if there is a wall, and how may cells away it is.
* [__Pololu 3081__](https://www.pololu.com/product/3081) _(U5, U4)_ - Motor encoders, used to keep track of wheel rotations.
* [__LM1085 (3A)__](http://www.ti.com/product/LM1085) _(U3)_ - Voltage regulator, a LDO regulator that gives a 5V source from the LiPo. 3A version.
* [__Switch__](http://www.google.com/search?q=mechanical+keyboard+switch) _(SW1)_ - Any mechanical keyboard switch
* [__Buzzer__](https://www.amazon.com/BETAFPV-Terminals-Electronic-Continuous-12X9-5mm/dp/B073RH8TQK) _(BZ1)_ - ~5mm buzzer pin spacing, the small ones in the link fit.
* [__LEDs__](http://www.google.com/search?q=3528+smd+led) _(D4, D5)_ - Any 3528 sized led rated for at least 3.3v
* __120Ω__ _(R0, R1, R2, R3)_ - Current limiting resistors for Emitters.
* __1.8KΩ__ _(R4, R5, R6, R7)_ - Current limiting resistor for Recievers.
* __...Ω__ _(R11)_ - Pull Up resistor for switch. Value based on the LED bought. [Calculate](http://www.ohmslawcalculator.com/led-resistor-calculator)
* __1-10kΩ__ _(R8, R9)_ - Current limiting resistors for LEDs.

<h2> Building Notes </h2>

1. Use header pins and sockets for the Teensy and Motor driver to make replacing parts easier.
1. With the ir emitters and receievers short end is positive.
1. When connecting wires to the motor encoder, make sure none of the wires are rubbing against the magnetic disk.
1. When connecting the encoder make sure to double check wires are connected correctly.
1. [Early Testing](https://github.com/lowj/micromouse-team/wiki/Meetings)

### Software Notes

#### Interrupts

* Interrupts are needed to keep track of the wheels revolution. When the wheels position changes, the motor encoder will send a signal to the Teensy. A total of 12 signals will be sent per 1 revolution. Interrupts allow it so the Teensy can update values as soon as the encoder sends the signal (asynchronously). If the encoders were updated in the main loop theres a good chance for some signals to be missed, causing the revolution count to be inaccurate.   

* To add an interrupt run the [attatchInterrupt](https://www.arduino.cc/reference/en/language/functions/external-interrupts/attachinterrupt/) function in setup. Syntax is **attatchInterrupt(pin, func, mode)**. The second parameter specifies the function that gets executed when the interrupt is triggered. In our case we want to put in a function that will add to the count of an encoder variable. The third parameter specifies what will trigger the interrupt. For example "CHANGE" will make the interrupt trigger whenever the pin changes value, however, "FALLING" will make the interrupt trigger only when the pin goes from HIGH to LOW. Read link for more info.

#### Variables

* tickCount - Two variables, one for each motor. When interrupt its triggered, increment the tick count by 1.
* emitterState - One for each emitter. Stores the current state of the emitter

#### Functions

* readReciever() - One method for each reciever. Returns the value read by reciever
* setEmitterState(x) - One method for each emitter. Set the state of the emitter to on or off.
* getSwitchState() - Return the value of the switch
* runMotorTime(m, speed, sec) - Set specific motor at speed for given amount of seconds. Uses delay function to count time.
* runMotorRev(m, speed, rev) - Runs a specific motor at speed for given amount of revolutions. Uses the encoder varible to count revolutions.
* setLED(l, brightness) - Sets a specific led to a certian brightness.
* setBuzzer(strength) - Sets the buzzer to a given strength.

#### More Functions
* turnRight() - Use encoders and tickCounts of both motors to make a percise right turn
* turnLeft() - similar to turnRight()
* goForward() - Use encoders to go straight.
* turnAround() - turnRight * 2

## KiCad design pcb_files/mouse/mouse_v2.kicad_pcb

Board: 2 copper layers, 84.9 x 94.9 mm, 56 parts (2 on the bottom side), 49 nets.

Parts:
BT1: Battery_Cell; PinSocket_1x02_P2.54mm_Vertical
BZ1: Buzzer; CST-931AP_buzzer
C2: 0.1uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C3: 1.0uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C9: 10uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C10: 10uF(Tantalum); C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D0, D1, D2, D3: IRL81A; LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm
D4, D5, D6: LED; LED_D5.0mm
J4: I2C_Conn; PinSocket_1x02_P2.54mm_Vertical
M1, M2: Motor_DC; Motor_mouse
MH1, MH2: M3; MountingHole_3.2mm_M3
Q0, Q1, Q2, Q3: Q_Photo_NPN; LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm
R1, R2, R3, R4, R18, R19, R20, R21: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6, R7, R8: 33; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9, R10, R11, R12: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R13, R14, R15, R16: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R17: R_PULL_UP; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
S1: EG1218; SWITCH_SLIDE_500SSP1S2M2QEA
S2: GPTS203211B; SW_PUSH_6mm
SK1, SK2: M3; MountingHole_3.2mm_M3
T0, T1, T2, T3: Q_NMOS_DGS; TN0104(TO-92)
U1: Teensy4.0; Teensy40
U2: SN754410NE (Half-Bridge); DIP254P762X508-16
U3: LM1085-5.0; TO-263-3_TabPin2
U4, U5: Encoder_3081; PinSocket_1x06_P2.00mm_Vertical

Connections:
/3.3v: Q0.1, Q1.1, Q2.1, Q3.1, R17.2, U1.16
/5v: C2.1, C3.1, D0.2, D1.2, D2.2, D3.2, S1.2, U1.33, U2.8, U2.16, U4.4, U5.4
/Buzzer: R18.1, U1.13
/Emitter_0: R9.2, U1.29
/Emitter_1: R10.2, U1.27
/Emitter_2: R11.2, U1.22
/Emitter_3: R12.2, U1.24
/GND: BT1.2, BZ1.2, C2.2, C3.2, C9.2, C10.2, D4.1, D5.1, D6.1, J4.1, R1.1, R2.1, R3.1, R4.1, R13.1, R14.1, R15.1, R16.1, S2.1, T0.3, T1.3, T2.3, T3.3, U1.1, U1.17, U2.4, U2.5, U2.12, U2.13, U3.1, U4.1, U5.1
/LED_1: R19.2, U1.20
/LED_2: R20.2, U1.25
/LED_3: R21.2, U1.26
/M1_backward: U1.2, U2.7
/M1_encoder_A: U1.10, U5.3
/M1_encoder_B: U1.11, U5.2
/M1_forward: U1.3, U2.2
/M1_speed: U1.6, U2.1
/M2_backward: U1.5, U2.15
/M2_encoder_A: U1.9, U4.3
/M2_encoder_B: U1.8, U4.2
/M2_forward: U1.4, U2.10
/M2_speed: U1.7, U2.9
/OUT1: U2.3, U5.5
/OUT2: U2.6, U5.6
/OUT3: U2.11, U4.5
/OUT4: U2.14, U4.6
/PUSH_SW: R17.1, S2.2, U1.14
/Reciever_0: Q0.2, R1.2, U1.30
/Reciever_1: Q1.2, R2.2, U1.28
/Reciever_2: Q2.2, R3.2, U1.21
/Reciever_3: Q3.2, R4.2, U1.23
/VUSB: S1.3, U1.34
/vBatt: BT1.1, C9.1, J4.2, U3.3
unnamed: BZ1.1, R18.2
unnamed: C10.1, S1.1, U3.2
unnamed: D0.1, R5.1
unnamed: D1.1, R6.1
unnamed: D2.1, R7.1
unnamed: D3.1, R8.1
unnamed: D4.2, R19.1
unnamed: D5.2, R20.1
unnamed: D6.2, R21.1
unnamed: R5.2, T0.1
unnamed: R6.2, T1.1
unnamed: R7.2, T2.1
unnamed: R8.2, T3.1
unnamed: R10.1, R14.2, T1.2
unnamed: R11.1, R15.2, T2.2
unnamed: R12.1, R16.2, T3.2
unnamed: R9.1, R13.2, T0.2

## KiCad design pcb_files/mouse/mouse.kicad_pcb

Board: 2 copper layers, 94.7 x 94.8 mm, 37 parts (9 on the bottom side), 39 nets.

Parts:
BAT: MountingHole_Pad; PinHeader_1x01_P2.54mm_Vertical
BT1: Battery_Cell; PinSocket_1x02_P2.54mm_Vertical
BZ1: Buzzer; 9x5.5mm Buzzer
D0, D1, D2, D3: IRL81A; LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm
D4: STATUS_0; 3528_SMD_LED
D5: STATUS_1; 3528_SMD_LED
GND: MountingHole_Pad; PinHeader_1x01_P2.54mm_Vertical
M1, M2: Motor_DC; Motor_mouse
M3: CASTER_BALL; Mouse_caster
Q0, Q1, Q2, Q3: Q_Photo_NPN; LED_D3.0mm_Horizontal_O3.81mm_Z2.0mm
R0, R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
SCL: MountingHole_Pad; PinHeader_1x01_P2.54mm_Vertical
SDA: MountingHole_Pad; PinHeader_1x01_P2.54mm_Vertical
SW1: SW_Push; MX
U1: Teensy3.2; Teensy30_31_32_LC
U2: SN754410NE; DIP254P762X508-16
U3: LM1084-5.0; PinHeader_1x03_P2.54mm_Vertical
U4, U5: Encoder_3081; PinSocket_1x06_P2.54mm_Vertical

Connections:
/3.3v: Q0.1, Q1.1, Q2.1, Q3.1, R11.2, U1.16
/5v: U1.33, U2.8, U2.16, U3.2, U4.4, U5.4
/Buzzer: R10.2, U1.24
/Emitter_0: R0.2, U1.30
/Emitter_1: R1.2, U1.29
/Emitter_2: R2.2, U1.27
/Emitter_3: R3.2, U1.28
/GND: BT1.2, BZ1.2, D0.1, D1.1, D2.1, D3.1, D4.1, D5.1, GND.1, R4.1, R5.1, R6.1, R7.1, SW1.1, U1.1, U1.17, U2.4, U2.5, U2.12, U2.13, U3.1, U4.1, U5.1
/M1_backward: U1.2, U2.7
/M1_encoder_A: U1.10, U5.3
/M1_encoder_B: U1.11, U5.2
/M1_forward: U1.3, U2.2
/M1_speed: U1.6, U2.1
/M2_backward: U1.5, U2.15
/M2_encoder_A: U1.8, U4.3
/M2_encoder_B: U1.9, U4.2
/M2_forward: U1.4, U2.10
/M2_speed: U1.7, U2.9
/OUT1: U2.3, U5.5
/OUT2: U2.6, U5.6
/OUT3: U2.11, U4.5
/OUT4: U2.14, U4.6
/PUSH_SW: R11.1, SW1.2, U1.14
/Reciever_0: Q0.2, R4.2, U1.23
/Reciever_1: Q1.2, R5.2, U1.22
/Reciever_2: Q2.2, R6.2, U1.20
/Reciever_3: Q3.2, R7.2, U1.21
/STATUS_LED_0: R8.2, U1.12
/STATUS_LED_1: R9.2, U1.13
/i2c_SCL: SCL.1, U1.26
/i2c_SDA: SDA.1, U1.25
/vBatt: BAT.1, BT1.1, U3.3
unnamed: BZ1.1, R10.1
unnamed: D0.2, R0.1
unnamed: D1.2, R1.1
unnamed: D2.2, R2.1
unnamed: D3.2, R3.1
unnamed: D4.2, R8.1
unnamed: D5.2, R9.1

## Commit log

2019-07-03 connections on encoders
2019-07-03 labeled pins
2019-07-05 status leds
2019-07-09 connected symbols to footprints
2019-07-09 binded footprints to symbols
2019-07-09 motor and wheel footprint
2019-07-09 mounting bracket to motor footprint
2019-07-09 caster ball footprint
2019-07-12 started basic layout
2019-07-12 added status LEDs, buzzer
2019-07-14 removed wirless module
2019-07-24 LED, Switch, Buzzer, footprints
2019-08-27 traces
2019-08-28 placed ir sensors
2019-08-29 traces finished
2019-08-29 cleaned up labels
2019-09-06 gerber
2019-09-06 plots.zip
2019-09-06 LED polarity markings
2019-09-06 ldo regulator labels
2019-09-06 shifted motors back 3mm
2019-09-06 fixed switch
2019-09-06 added version label
2019-09-08 updated gerber files
2019-12-24 added mosfets to schematic
2019-12-24 fixed reciever not connected to analog pin
2019-12-25 started new pcb
2019-12-26 added resistor layout
2019-12-26 arranged resistor footprints
2019-12-27 draft 1 layout
2019-12-27 pikachuuu ʕ·ᴥ·ʔ
2019-12-28 moved labels
2019-12-28 added label for encoder socket
2019-12-28 Update README.md
    updated schematic, and 3d renders
2019-12-29 added gnd vias
2019-12-29 added filter capictors
2019-12-29 slightly moved button
2019-12-29 fixed caster position interfering with ir emitters
2019-12-30 rerouted traces
2020-01-06 gerber files
2020-01-06 added version number
2020-01-06 updated plots to have new mouse gerbers
2020-01-30 Fixed Emitter1, Reciever1 Labels
2020-02-21 Started esp32 version
2020-03-10 started new design
2020-03-19 modified battery layout
2020-03-19 added rgb led to schematic
2020-03-19 Replaced LDO with LM2569 buck converter
2020-03-20 sectioned schematic
2020-03-21 test
2020-03-21 test1
2020-03-21 paired footprints with almost all compoennts
2020-03-22 Created footprint for inductor
2020-03-23 reverted back to LDO
2020-03-23 added rgb led, and button
2020-03-29 finished schematic
2020-03-29 fixed drc errors on schematic
2020-03-30 reworked mouse shape
2020-03-30 Start of v3.0
2020-03-30 fixing bug causing 3.3v and 5v nets connected
2020-03-30 working on layout
2020-03-30 started footprint for usb c connector
2020-03-31 created USB C footprint
2020-03-31 added usb c, rounded edges
2020-03-31 started tracing
2020-03-31 wired emitters/recievers, 5v+3.3v bus on bottom
2020-03-31 teensy header for microusb breakout smd pads
2020-03-31 added mico usb header to schematic
2020-03-31 swapping pins on teensy to make tracing easier
2020-03-31 finished traces, except gnd net
2020-04-01 ground planes, via stitches
2020-04-01 added keep out under usb c port
2020-04-01 removing old labels
2020-04-01 created correct footprint for slide switch
2020-04-01 cleaned up labeling on front silk
2020-04-01 todo: check angles of front two sensors
2020-04-02 added wall guide lines to PCB
2020-04-02 deleted GND text in copper layer causing DRC to fial
2020-04-02 analog gnd, removed coppor pour under battery spot
2020-04-02 generated gerber files
2020-04-02 added fish and name to board
2020-05-18 testing files
2020-05-18 tested: emiters/recivers, Buzzer, buttons, LEDS
2020-05-19 ran basic motor tests
2020-05-22 added to test file
2020-07-30 Library updates
2020-07-31 Kit mouse before slimming
2020-07-31 Fixed reciever/emitter pins
2020-08-06 Slimmed Model
2020-08-07 deleted files in fish-mouse folder
2020-08-12 SMD Caps, Space for Skates, Smaller Switch
2020-08-14 Update on PCB reforms
2020-08-15 kit mouse updated
2020-08-15 Uploaded New Images
2020-08-16 Kit mouse updates
2020-08-16 deleted excess files
2020-08-16 Connected ground planes
2020-08-16 cleand up edges
2020-08-16 fixes
2020-08-16 Names, connection fixes
2020-08-16 cleaned up labeling and files
2020-08-16 createwd new buzzer footprint
2020-08-16 updated buzzer footprinton pcb
2020-08-17 added labels
2020-09-11 Revert "Merge pull request #1 from micromouseuci/master"
    This reverts commit 81f41dff6f967f290da081a73f27f59054307190, reversing
    changes made to c249436bbf530991122370004db730883dee9d26.
2020-10-12 platform io for testing basical functionality
    basic functionality works, emit/recievers, buzer, motors, buttons, encoders. rgb leds cannont control brightness :(
2020-10-21 housekeeping
2021-02-09 created skate designs
2021-03-31 stress test code
